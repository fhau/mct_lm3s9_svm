# Keil uVision project hsa_project.uvproj, settings and files
target SVM (ARM-ADS)
  device: LM3S9D96 Texas Instruments
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0-0x7FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: hsa_project
  c flags: Optim=1
  c include: ..\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source
    ../: main.c Startup.s setclock.s rs232.c system.c GPIO.c ADC.c
  group Header
    ../inc/: lm3s9d96.h labex.h
